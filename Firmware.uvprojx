# Keil uVision project Firmware.uvprojx, settings and files
target Firmware (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.51
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PS2_Keyboard_Mouse_to_USB +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: Sources;.\Libraries\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library;.\Includes\Keyboard
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sources
    ./Sources/: hid.h hiduser.c hiduser.h main.c main.h MDR32F9Qx_config.h type.h usb.h usbcfg_MDR32F9x.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbhw_MDR32F9x.c usbhw_MDR32F9x.h usbreg_MDR32F9x.h usbuser.c usbuser.h systick.c systick.h MDR32F9Qx_usb_device.c uart.c kbms.c ps2phy.c ps2protocol.c queue.c matrix.c config.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.5, Drivers:PORT 1.5, Drivers:POWER 1.5, Drivers:RST_CLK 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5, Drivers:USB 1.5
